# Repository DaveBerkeley/kicad

## KiCad design arduino/arduino.kicad_pcb

Board: 2 copper layers, 45.7 x 45.7 mm, 14 parts (0 on the bottom side), 19 nets.

Parts:
0 batt +: battery; PIN_ARRAY_2X1
Ant.: CONN_1; PIN_ARRAY_1
Aux.: CONN_6; PIN_ARRAY-6X1
C1: C; C2
C2, C4: 0.1u; C2
C3: 10u; C1V5
IC1: ATMEGA328P-P; DIP-28__300
P1, P2: CONN_6; PIN_ARRAY-6X1
Q1: 16MHz; murata-resonators-CSTLS_G8
R1: 10k; R4
Rx/Tx: CONN_6; PIN_ARRAY-6X1
pwr: CONN_2; PIN_ARRAY_2X1

Connections:
GND: 0 batt +.1, Aux..6, C1.2, C2.2, C3.2, IC1.8, IC1.22, P1.3, P2.3, Q1.2, Rx/Tx.1
unnamed: C4.1, IC1.1, R1.1
unnamed: IC1.10, Q1.1
unnamed: IC1.9, Q1.3
unnamed: IC1.6, P1.2
unnamed: IC1.24, P2.5
unnamed: IC1.23, P1.5
unnamed: IC1.11, P2.2
unnamed: IC1.5, P1.6, P2.6
unnamed: Aux..1, IC1.15
unnamed: Aux..4, IC1.12
unnamed: Aux..3, IC1.13
unnamed: Aux..2, IC1.14
unnamed: Rx/Tx.3, pwr.2
unnamed: IC1.3, Rx/Tx.5
unnamed: IC1.2, Rx/Tx.4
unnamed: C4.2, Rx/Tx.6
unnamed: C1.1, IC1.21
VCC: 0 batt +.2, Aux..5, C2.1, C3.1, IC1.7, IC1.20, P1.1, P1.4, P2.1, P2.4, R1.2, pwr.1

## KiCad design optical_mouse/optical_mouse.kicad_pcb

Parts:
??1: ANDS-2610
C1: C
C2, C3: CP1
D1, D2, D3, D4: LED
Q1: CSTLS_G; murata-resonators-CSTLS_G8
R1, R2, R3, R4: R
U1: ARDUINO_MINI; DIL20

Connections:
+5V: ??1.7 (VDD), C1.1, C2.1, R1.1, R2.1, R3.1, R4.1, U1.12; also elsewhere on the board
GND: ??1.6 (GND), C1.2, C2.2, C3.2, Q1.2 (VSS), U1.14, U1.19; also elsewhere on the board
unnamed: D4.1 (A), R4.2
unnamed: D2.2 (K), U1.29
unnamed: D1.1 (A), R1.2
unnamed: D2.1 (A), R2.2
unnamed: D3.1 (A), R3.2
unnamed: D3.2 (K), U1.21
unnamed: D4.2 (K), U1.20
unnamed: D1.2 (K), U1.30
unnamed 10: U1.22; also elsewhere on the board
unnamed 11: U1.23; also elsewhere on the board
unnamed 12: ??1.2 (OSC_OUT), Q1.1; also elsewhere on the board
unnamed 13: ??1.1 (OSC_IN), Q1.3; also elsewhere on the board
unnamed 14: ??1.8 (REFA), C3.1; also elsewhere on the board

Board: 2 copper layers, 48.3 x 45.7 mm, 14 parts (0 on the bottom side), 15 nets.

Other parts of the board:
U2: adns-2610-DIP-8_(GORA)

Their connections:
+5V: U2.7; also elsewhere on the board
GND: U2.6; also elsewhere on the board
unnamed 10: U2.4; also elsewhere on the board
unnamed 11: U2.3; also elsewhere on the board
unnamed 12: U2.2; also elsewhere on the board
unnamed 13: U2.1; also elsewhere on the board
unnamed 14: U2.8; also elsewhere on the board

## Commit log

2013-01-07 initial
2013-01-07 add ignores
2013-01-07 copy from dev PC
2013-01-07 moved to subdir
2013-01-07 renamed file typo
2013-01-07 remve old file
2013-01-07 move *.lib *.mod and *.dcm into lib dir
2013-01-07 work in progress
2013-01-07 added .bck to ignore
2013-01-07 added local cache files. Should these be here?
2013-01-07 moved block over
2013-01-07 remove *.bck
2013-01-10 testing
2013-01-25 relayed and added rx/tx connector
2015-05-29 added arduino nano library from http://www.kicadlib.org/
2015-05-29 start work on optical mouse pcb
2015-05-29 added adns-2610 components
2015-05-29 first stab at circuit
2015-05-29 first attempt at pcb - need more component definitions
2015-05-29 added 3-pin ceramic resonator to lib
2015-05-31 added murata-resonators
2015-05-31 first viable layout
2015-05-31 make room for mounting holes
2015-05-31 more space for holes
2015-05-31 more messing with mounting holes
2015-05-31 added gnd plane
2015-05-31 gerber files etc
2015-05-31 added hole to lib
2015-05-31 re-layed out with correct mouse part
2015-05-31 remove gerber files
2015-05-31 remove report files
2015-05-31 addes bash script to generate gerber zip file
2015-05-31 ensure camera hole is drilled in seedstudio
2015-05-31 add gerber files to git ignore
2015-05-31 mirror copyright text
2015-05-31 tweak fill
2015-05-31 churn
2015-05-31 removed unused lib files
2015-05-31 remove pcb text
2015-05-31 minor changes
2015-05-31 move camera hole into module
2015-05-31 added vi swap file to ignore
2015-05-31 improve gerber zip script
2015-05-31 moved gerber zip script
2015-05-31 update library with edited modules
2015-05-31 removed bad library
2015-05-31 minor edits
2015-05-31 extract holes and board edge from gerber - wip
2015-05-31 wip - extract board dims
2015-05-31 parsing gerber edge file
2015-06-01 read gerber units. refactor
2015-06-01 added opts
2015-06-01 changed track for more ground plane
2015-06-01 make unique zip filename
2015-06-01 remove old tiny radio stuff
2015-06-01 make gnd trace thicker at pinch point
2015-06-04 arrange LEDs around circle
2015-06-04 minor moves
2015-06-05 added gerbv project file
2015-07-08 added LPC1114FN28 library
2015-07-13 added Atmel library
2015-07-13 first steps
2015-07-13 main circuit in place
2015-07-13 associate footprints
2015-07-13 start on pcb
2015-07-13 first valid layout - added connector
2015-07-13 change connectors
2015-07-13 added gerber files to ignore
2015-07-13 more pcb work
2015-07-13 remove ground plane temporarily
2015-07-13 wip : moving parts about
2015-07-14 moving traces slightly
2015-07-14 shrink board, add mounting holes
2015-07-14 add cladding
2015-07-14 resize board
2015-07-14 added ground planes
2015-07-14 ignore pcb.png
2015-07-14 add battery connector
2015-07-14 pcb text
2015-07-14 rotated C
2015-07-15 added ESP-03 schematic
2015-07-15 thicken power traces
2015-07-15 swap pins 15/16 on cpu
2015-07-15 fix port labels
